<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hsl_bpsk_ax25_rx</value></param>
<param><key>author</key><value>Ido</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>HSL BPSK AX25 RX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>str(packets_port_rx)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>hsl_bpsk_ax25_demod</key>
<param><key>id</key><value>hsl_bpsk_ax25_demod_0</value></param>
<param><key>baudrate</key><value>9600</value></param>
<param><key>costas_loop_bw</key><value>2*math.pi/200</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
<param><key>fll_loop_bw</key><value>2*math.pi/350</value></param>
<param><key>max_cfo</key><value>4e3</value></param>
<param><key>rf_samp_rate</key><value>2.4e6</value></param>
<param><key>symbol_Sync_loop_bw</key><value>2*math.pi/100</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packets_port</value></param>
<param><key>label</key><value>TCP Port (ZMQ)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52002</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tcp_port</value></param>
<param><key>label</key><value>TCP Port (ZMQ)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6001</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:'+str(tcp_port)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>hsl_bpsk_ax25_demod_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>hsl_bpsk_ax25_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
