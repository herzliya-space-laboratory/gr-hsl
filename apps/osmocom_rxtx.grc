<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hsl_osmocom_rx_tx</value></param>
<param><key>author</key><value>Ido</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>HSL Osmocom RX TX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_correction</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_args</value></param>
<param><key>label</key><value>Device Arguments</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_port_rx</value></param>
<param><key>label</key><value>Doppler Port RX</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>7355</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_port_tx</value></param>
<param><key>label</key><value>Doppler Port TX</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>7356</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>rx_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>hsl_doppler_correction_cc</key>
<param><key>id</key><value>hsl_doppler_correction_cc_0</value></param>
<param><key>base_freq</key><value>tx_freq</value></param>
<param><key>port</key><value>doppler_port_tx</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>hsl_doppler_correction_cc</key>
<param><key>id</key><value>hsl_doppler_correction_cc_0_0</value></param>
<param><key>base_freq</key><value>rx_freq</value></param>
<param><key>port</key><value>doppler_port_rx</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>ant0</key><value>tx_antenna</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>tx_freq-tx_offset+freq_correction</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>args</key><value>device_args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_tx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>rx_antenna</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>rx_freq-rx_offset+freq_correction</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rx_rf_gain</value></param>
<param><key>args</key><value>device_args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_antenna</value></param>
<param><key>label</key><value>RX Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>436.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_port</value></param>
<param><key>label</key><value>RX TCP Port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_rf_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>label</key><value>Sample Rate RX</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>label</key><value>Sample Rate TX</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_antenna</value></param>
<param><key>label</key><value>TX Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>145.97e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_port</value></param>
<param><key>label</key><value>TX TCP Port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6002</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:'+str(rx_port)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:'+str(tx_port)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>hsl_doppler_correction_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_doppler_correction_cc_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_doppler_correction_cc_0_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>hsl_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
