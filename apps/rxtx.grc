<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hsl_rx_tx</value></param>
<param><key>author</key><value>Ido</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>HSL RXTX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_correction</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>"localhost"</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>packets_port_rx</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>packets_port_tx</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>7350</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>7351</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>7352</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0_0_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>7353</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_args</value></param>
<param><key>label</key><value>Device Arguments</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_port_rx</value></param>
<param><key>label</key><value>Doppler Port RX</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7355</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_port_tx</value></param>
<param><key>label</key><value>Doppler Port TX</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7356</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>rx_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gui_port_clock</value></param>
<param><key>label</key><value>GUI Port Clock</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7351</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gui_port_costats</value></param>
<param><key>label</key><value>GUI Port Costas</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7352</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gui_port_fll</value></param>
<param><key>label</key><value>GUI Port FLL</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7353</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gui_port_wide</value></param>
<param><key>label</key><value>GUI Port Wide</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7350</value></param>
</block>
<block>
<key>hsl_afsk_ax25</key>
<param><key>id</key><value>hsl_afsk_ax25_0</value></param>
<param><key>baud_rate</key><value>1200</value></param>
<param><key>mark_freq</key><value>1200</value></param>
<param><key>postamble_len</key><value>4</value></param>
<param><key>preamble_len</key><value>.1</value></param>
<param><key>rf_samp_rate</key><value>2.4e6</value></param>
<param><key>space_freq</key><value>2200</value></param>
<param><key>offset</key><value>tx_offset</value></param>
</block>
<block>
<key>hsl_bpsk_ax25</key>
<param><key>id</key><value>hsl_bpsk_ax25_0</value></param>
<param><key>baudrate</key><value>9600</value></param>
<param><key>costas_loop_bw</key><value>2*math.pi/200</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
<param><key>fll_loop_bw</key><value>2*math.pi/350</value></param>
<param><key>max_cfo</key><value>4e3</value></param>
<param><key>rf_samp_rate</key><value>2.4e6</value></param>
<param><key>symbol_Sync_loop_bw</key><value>2*math.pi/100</value></param>
</block>
<block>
<key>hsl_doppler_correction_cc</key>
<param><key>id</key><value>hsl_doppler_correction_cc_0</value></param>
<param><key>base_freq</key><value>tx_freq</value></param>
<param><key>port</key><value>doppler_port_tx</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
</block>
<block>
<key>hsl_doppler_correction_cc</key>
<param><key>id</key><value>hsl_doppler_correction_cc_0_0</value></param>
<param><key>base_freq</key><value>rx_freq</value></param>
<param><key>port</key><value>doppler_port_rx</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>ant0</key><value>tx_antenna</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>tx_freq-tx_offset+freq_correction</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>args</key><value>device_args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_tx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>rx_antenna</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>rx_freq-rx_offset+freq_correction</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rx_rf_gain</value></param>
<param><key>args</key><value>device_args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packets_port_rx</value></param>
<param><key>label</key><value>Packets Port RX</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52002</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packets_port_tx</value></param>
<param><key>label</key><value>Packets Port TX</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52001</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>192e3/samp_rate_rx</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_antenna</value></param>
<param><key>label</key><value>RX Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>436.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_rf_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>70</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>label</key><value>Sample Rate RX</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>label</key><value>Sample Rate TX</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_antenna</value></param>
<param><key>label</key><value>TX Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>145.97e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>hsl_afsk_ax25_0</sink_block_id><source_key>pdus</source_key><sink_key>packets</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>hsl_doppler_correction_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_afsk_ax25_0</source_block_id><sink_block_id>hsl_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_bpsk_ax25_0</source_block_id><sink_block_id>blocks_udp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_bpsk_ax25_0</source_block_id><sink_block_id>blocks_udp_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_bpsk_ax25_0</source_block_id><sink_block_id>blocks_udp_sink_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_bpsk_ax25_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hsl_doppler_correction_cc_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_doppler_correction_cc_0_0</source_block_id><sink_block_id>hsl_bpsk_ax25_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_doppler_correction_cc_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
