<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hsl_afsk_ax25_tx</value></param>
<param><key>author</key><value>Ido</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>HSL AFSK AX25 TX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>str(packets_port)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>hsl_afsk_ax25_mod</key>
<param><key>id</key><value>hsl_afsk_ax25_mod_0</value></param>
<param><key>baud_rate</key><value>baud_rate</value></param>
<param><key>mark_freq</key><value>1200</value></param>
<param><key>postamble_len</key><value>4</value></param>
<param><key>preamble_len</key><value>.1</value></param>
<param><key>rf_samp_rate</key><value>samp_rate</value></param>
<param><key>space_freq</key><value>2200</value></param>
<param><key>offset</key><value>offset</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offset</value></param>
<param><key>label</key><value>Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packets_port</value></param>
<param><key>label</key><value>Packets Port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tcp_port</value></param>
<param><key>label</key><value>TCP Port (ZMQ)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6002</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>'tcp://127.0.0.1:'+str(tcp_port)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>hsl_afsk_ax25_mod_0</sink_block_id><source_key>pdus</source_key><sink_key>packets</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hsl_afsk_ax25_mod_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
